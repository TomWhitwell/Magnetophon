File: Hardware/magnetophone.brd (EAGLE design)
At the start: 105 x 19 mm, 22 parts, among them U2 TL072_

Commit message: Tweaks
Parts:
- R16: value 220R -> 200R
